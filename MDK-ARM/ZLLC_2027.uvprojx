# Keil uVision project ZLLC_2027.uvprojx, settings and files
target ZLLC_2027 (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: ZLLC_2027 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32H723xx,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM7,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../User/Congfig/Inc;../User/Task/Inc;../User/Interaction/Inc;../User/Chariot/Inc;../User/Device/Inc;../User/Driver/Inc;../User/Algorithm/Inc;../Drivers/CMSIS/Include;../DSP;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\ekf_tcm.sct
  group Config
    ../User/Congfig/Src/: config.cpp
  group Task
    ../User/Task/Src/: freertos_tasks.cpp tsk_config_and_callback.cpp
    ../User/Task/Inc/: freertos_tasks.h
  group Interaction
    ../User/Interaction/Src/: ita_chariot.cpp
  group Chariot
    ../User/Chariot/Src/: crt_booster.cpp crt_chassis.cpp crt_gimbal.cpp
  group Device
    ../User/Device/Src/: dvc_boardc_bmi088.cpp dvc_djimotor.cpp dvc_dmmotor.cpp dvc_dr16.cpp dvc_Fs_i6x.cpp dvc_dwt.cpp dvc_performance.cpp dvc_imu.cpp dvc_lkmotor.cpp dvc_minipc.cpp dvc_referee.cpp dvc_supercap.cpp dvc_VT13.cpp dvc_GraphicsSendTask.cpp dvc_TensionMeter.cpp dvc_servo.cpp dvc_dmimu.cpp buzzer.c buzzer_bsp.c
  group Driver
    ../User/Driver/Src/: drv_adc.cpp drv_bsp-boarda.cpp drv_can.cpp drv_dwt.cpp drv_i2c.cpp drv_math.cpp drv_spi.cpp drv_tim.cpp drv_uart.cpp drv_usb.cpp
    ../User/Driver/Inc/: drv_can.h
  group Algorithm
    ../User/Algorithm/Src/: alg_VQF.cpp alg_filter.cpp alg_fsm.cpp alg_MahonyAHRS.cpp alg_pid.cpp alg_slope.cpp kalman_filter.cpp PID.cpp QuaternionEKF.cpp user_lib.cpp alg_new_power_limit.cpp
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Freertos
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
  group Validation
    ../Tools/: check_can_fd.py can_fd_tests.cpp check_cubemx.py check_priorities.py
    ../: README.md ZLLC_2027.ioc
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
